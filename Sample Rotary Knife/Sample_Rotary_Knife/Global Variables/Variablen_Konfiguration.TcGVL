{attribute 'Tc2GvlVarNames'}
VAR_CONFIG
END_VAR
